# IAR project samovar.ewp, settings and files
configuration samovar (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073V8 ST STM32L073V8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32L073xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: samovar.hex
  ILINK.IlinkOutputFile: samovar.out
  ILINK.IlinkIcfFile: stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l073xx.s
  group Application/User
    ./: hsv2rgb.cpp Tbubble.cpp Tcoals.cpp Tled_color.cpp
  group Application/User/Core
    ../Core/Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_rcc.c stm32l0xx_ll_adc.c stm32l0xx_ll_dac.c stm32l0xx_ll_gpio.c stm32l0xx_ll_rcc.c
